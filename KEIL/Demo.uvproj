# Keil uVision project Demo.uvproj, settings and files
target Demo (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: Demo +hex
  AfterMake: ..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\Library;..\Main;..\Library\Device\Include;..\Main\0AC;..\Main
  group Main
    ../Main/: Main.c Sys_Init.c Sys_Time0_IRQ.c Sys_Adc.c Sys_Uart0_IRQ.c App_BT_Uart0.c App_Key.c App_Charge_bat.c App_Hall.c App_pwr_off.c App_iap_info.c App_led.c APP_Adc.c App_Reset_BT.c APP_EMR_Power.c APP_Low_Power_Mode.c APP_External_Interrupt_0.c APP_Pin_Interrupt.c
  group Library
    ../Main/: Delay.c
  group Startup
    ../Library/Startup/Keil/: STARTUP.A51
